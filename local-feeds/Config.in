## local-feeds/Config.in
```kconfig
menu "local-feed pkgs"
    source "package/feeds/local_feeds/*/Config.in"
endmenu
```
